Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], ExchangeRequirement []
File name: Project Number
Time: 2022-05-13T10:18:14+01:00
Written by: ODA SDAI 22.12
Made in: 23.0.1.318 - Exporter 23.0.1.318 - Default UI

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 415405; RefLongitude: -71, -3, -24, -318237; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingElementProxy: NLRS_57_DUA_UN_round firedamper fdc25_sacs:FDC25 O EX O, NLRS_57_DUA_UN_round firedamper fdc25_sacs:FDC25 O EX O:1096694
In: Default
Type - Description: Ronde brandklep; Classification: 57.70 (Uniformat); Material: Belimo_Black (8), NLRS_A_SACS_SVZ (2)
Type - Constraints - Default Elevation: 0 mm
Type - General - Article_Data: FDC25_Article_Data; Selection_Factors: Selection_Factors
Type - Identity Data - Assembly Code: 57.70; Description: Ronde brandklep; Manufacturer: Solid Air Climate Solutions; Model: Brandklep - Rond; NLRS_C_content_creator: J. Feeke; NLRS_C_content_datum_uitgifte: 19-01-2022; NLRS_C_content_provider: Solid Air Climate Systems; NLRS_C_content_versie: Versie 3.19.00; NLRS_C_description: Ronde brandklep; NLRS_C_niveau ontwikkeling: LOD400; Type Name: FDC25 O EX O; URL: https://solid-air.nl/producten/solid-air-ronde-brandklep-fdc25/
Type - Materials and Finishes - Blade material: Hittebestendig dikte 25mm; Casing material: Gegalvaniseerd plaatstaal; Fuse temperatuur (default): 72 °C
Type - Other - Category: Duct Accessories; Family Name: NLRS_57_DUA_UN_round firedamper fdc25_sacs
Type - Visibility - Show Symbol: yes
Type - Pset_ConcreteElementGeneral - FireRating: EN 1366-2 and EN 13501-3, 2h
Type - Pset_ManufacturerTypeInformation - Manufacturer: Solid Air Climate Solutions
Type - Pset_ProductRequirements - Category: Duct Accessories
Pset_BuildingElementProxyCommon - Reference: FDC25 O EX O; sets with these values: 2
Pset_ProvisionForVoid - Width: 210 mm; Height: 95 mm; Depth: 296 mm
Constraints - Elevation from Level: 0 mm
Dimensions - Area: 0.00602958 m2; NLRS_C_lengte: 296 mm; NLRS_M_c01_diameter: 200 mm; SACS_Duct_Used_Size: 200 mm; Volume: 0.00000197509 m3
Graphics - Use Annotation Scale: no
Identity Data - Mark: 11945; NLRS_C_model: FDC25 O EX O 200; SACS_Article_Code: NB; SACS_Gross_Cost: 0; SACS_Price_Date: 0
Insulation - Insulation Thickness: 0 mm
Lining - Lining Thickness: 0 mm
Mechanical - System Classification: Undefined
Mechanical - Flow - NLRS_M_c01_debiet: 0 m3/s; NLRS_M_c01_drukverlies_statisch: 0 Pa; SACS_Air_Velocity: 0 m/s; SACS_Lp_dBA: 0; SACS_Manual_Airflow: 0 m3/s; SACS_Nominal_Max_Flow: 376.944 m3/s; SACS_Nominal_Min_Flow: 47.2222 m3/s; SACS_Use_Manual_Airflow: yes
Model Properties - SACS_Belimo_Rotation (1-3): 1; SACS_Option_1: O = geen frame; SACS_Option_2: EX = Schischek 230/24 servo explosieveilig; SACS_Option_3: O = Geen Accessoire
Other - Family: NLRS_57_DUA_UN_round firedamper fdc25_sacs; Family and Type: NLRS_57_DUA_UN_round firedamper fdc25_sacs: FDC25 O EX O; Type: FDC25 O EX O; Type Id: 1096610
Phasing - Phase Created: New Construction
Visibility - SACS_Disable_Warning: no

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCEANDSINK
